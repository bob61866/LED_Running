# Keil uVision project LED_Running.uvprojx, settings and files
target LED_Running (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: LED_Running +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\Library\inc;.\Library\CMSIS;.\User;.\Start
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s
  group Library
    ./Library/src/: stm32f10x_gpio.c stm32f10x_rcc.c
  group CMSIS
    ./Library/CMSIS/: system_stm32f10x.c
  group User
    ./User/: main.c
